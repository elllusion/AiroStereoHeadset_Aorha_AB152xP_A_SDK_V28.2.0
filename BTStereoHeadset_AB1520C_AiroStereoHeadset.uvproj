# Keil uVision project BTStereoHeadset_AB1520C_AiroStereoHeadset.uvproj, settings and files
target Release_Flash (MCS-251)
  device: DQ80251CFG Digital Core Design
  cpu: IRAM(0 - 0x1000) CLOCK(50000000) IROM(0xFF0000-0xFFFFFF)
  output: BTStereoHeadset_AB1520C_AiroStereoHeadset +hex
  asm define: FLASH_INIT=1,AB1520C=1,MIGRATE_ROM_TO_FLASH=1,DFU_LOADER_IN_BOOT_CODE=1
  asm include: .\source\common;.\source\ROM\COMMON
  group Rom
    ./source/ROM/COMMON/: VECTOR.ASM CTXSW.obj align_osmem.obj align_osmq.obj bt_clock.obj bt_timer.obj rc.obj sys_speedup.obj sys_air_update_mode.obj sys_eng_mode.obj bt_clock_speedup.obj crc8.c crc16.c crc16_speedup.asm dfu_loader.c msg_offset.obj
    ./source/ROM/DRIVER/: drv_3wire.c drv_adc0.obj drv_dma.obj drv_gpio.obj drv_pmu.obj drv_prbs.obj drv_sector.obj drv_spi.obj drv_spiflash.c drv_program_flash.c drv_flash_AB1520C.c drv_watchdog.obj drv_charger.obj drv_xport.obj drv_uart.obj drv_keypad.obj drv_adc1.obj
    ./source/ROM/HAL/: drv_spi_hal.obj drv_gpio_hal.obj bt_timer_hal.obj bt_timer_speedup.obj drv_3wire_speedup.asm drv_dma_speedup.obj drv_gpio_speedup.obj drv_adc0_speedup.obj drv_btclk_speedup.obj drv_prbs_speedup.obj drv_uart_hal.obj drv_adc1_hal.obj
    ./source/ROM/OS/: os.obj os_dpc.obj os_heap.c os_intr.obj os_intr_ext1.obj os_intr_ext1_pmu.obj os_list.obj os_list_speedup.obj os_memory.obj os_memory_speedup.obj os_speedup.obj os_task.obj os_task_speedup.obj os_timer.obj os_timer_speedup.obj
    ./source/ROM/HC/: hc.obj HC_DbgPrint.obj HC_VCMD.obj
    ./source/ROM/LL/: LL.obj LL_connection.obj LL_enc.obj LL_info_exchange.obj LL_init.obj LL_semaphore.obj LL_adv_report.obj LL_data_length_update.obj
    ./source/ROM/LC/: lc.obj LC_Initiating.obj LC_Advertising.obj LC_BLE.obj LC_CommonConnection.obj LC_DirectTestmode.obj LC_Inquiry.obj LC_InquiryScan.obj LC_ISRHandler.obj LC_LabTest.obj LC_LE_FlowCtl.obj LC_Master.obj LC_MasterRoleSwitch.obj LC_PageScan.obj LC_Scanning.obj LC_Slave.obj LC_SlaveRoleSwitch.obj lc_speedup.obj LC_Standby.obj LC_Testmode.obj LC_LE_LabTest.obj LC_Page.obj LC_RssiScan.obj
    ./source/ROM/L2CAP/: L2CAP_ROM.obj
    ./source/ROM/GAP/: GAP_ROM.obj
    ./source/ROM/MMI_LE/: MMI_LE_ROM.obj
    ./source/ROM/ATT/: ATT_AU.obj DES.obj
    ./source/ROM/KERNEL/: hci_conn_hdl.obj hci_xport.obj hci_h5.obj
  group STARTUP251
    ./source/STARTUP251/: STARTUP251.obj main.obj INITEDAT.A51
  group COMMON
    ./source/COMMON/: flash_descriptor_AtBegin.c flash_descriptor.obj BootCode.obj sys_ctlr_mode.obj sys_device_mode.obj le_common_hal.obj sys_clk_ctl.obj
    ./source/Common/: rc_flash.obj align_flash.obj
  group SECTOR_HEADER
    ./source/SECTOR/Config0/: sector_config0_header.c
    ./source/SECTOR/Config1/: sector_config1_header.c
    ./source/SECTOR/DspData/: sector_dsp_data_header.c
    ./source/SECTOR/SectorBoundary/: sector_boundary_header.c
    ./source/SECTOR/VoiceData/: sector_voice_data_header.c
    ./source/SECTOR/ToolMisc/: sector_tool_misc_header.c
    ./source/SECTOR/Runtime/: sector_merge_runtime_header_1.c sector_merge_runtime_header_2.c sector_runtime_header.c
  group SECTOR_CONFIG
    ./source/SECTOR/: sector_a2dp_nvram_ctl_type.c sector_driver_led_data_type.c sector_driver_ringtone_data_type.c sector_hc_parameter_type.c sector_lc_misc_ctl.c sector_lm_parameter_type.c sector_mcu_dsp_parameter_init.obj sector_mmi_nvram_keymap.c sector_mmi_nvram_type.c sector_sys_local_device_control_type.c sector_sys_local_device_info.c sector_sys_local_device_EIR.c sector_sys_memory_config.c sector_mmi_driver_nvram_backup_type.c sector_sm_nvram_type.c sector_uart_parameter.c sector_gap_nvram_type.c sector_tool_info.c sector_ae_info.c sector_driver_ctl_type.obj sector_application.c sector_iap2_type.c sector_uart_parameter_eng.c sector_le_misc_ctl.c sector_sys_patch_code_init.c sector_dsp_vp_nb.obj sector_spi_config.c sector_driver_reserved_data_type.c sector_dsp_peq_param_type.c sector_dsp_hpf_param_type.c
    ./source/SECTOR/Config0/: sector_afe_init.c sector_sfr_init.c sector_rf_misc_ctl.c sector_hw_misc_ctl.c
  group SECTOR_4KALIGN
    ./source/SECTOR/: sector_mp_parameter.c sector_mmi_driver_variation_nvram_type2.c sector_mmi_le_variation_nvram_type2.c sector_dual_mic_data2.c sector_mmi_driver_variation_nvram_type.c sector_mmi_le_variation_nvram_type.c sector_dual_mic_data.c sector_dsp_func_para.c sector_app_callername_data.obj sector_mmi_customize_v_nvram2.c sector_mmi_customize_v_nvram.c sector_mp_parameter_F.c sector_dsp_peq_hpf_param_custom_type.c
  group ABSDRIVER
    ./source/ABSDRIVER/: drv_flash_flash.obj drv_sector_flash.obj drv_pmu_flash.obj drv_adc0_flash.obj drv_program_flash_flash.obj I2C.obj drv_spi_flash.obj drv_led.obj drv_i2s.obj drv_uart_transparent.obj drv_gpio_flash.obj drv_spi_slave.obj
  group OS
    ./source/OS/: os_flash.obj os_memory_bootcode.asm
  group HC
    ./source/HC/: hc_flash.obj hci_xport_flash.obj INT1_ISRHandler.obj HC_VCMD_flash.obj ChAssess_Hdlr.obj
  group LM
    ./source/LM/: LM.obj LM_AFH.obj LM_AnyTimePDU.obj LM_AuthEnc.obj LM_CheckFeatures.obj LM_ConnectSetup.obj LM_CreateConnection.obj LM_CreateSynchronousConnection.obj LM_Detach.obj LM_ExtendedSynchronousConnectSetup.obj LM_ExtendedSynchronousDisconnect.obj LM_Hold.obj LM_InformationRequest.obj LM_Inquiry.obj LM_Misc.obj LM_PacketTypeChange.obj LM_PowerControl.obj LM_QoS.obj LM_RoleSwitch.obj LM_Security.obj LM_SecurityTable.obj LM_SimplePairing.obj LM_SniffMode.obj LM_SynchronousConnectSetup.obj LM_SynchronousDisconnect.obj LM_Testmode.obj LM_VCMD.obj
  group LC
    ./source/LC/: lc_flash.obj
  group DRIVER
    ./source/DRIVER/: Audio_MailBox.c AudioControl.obj DRIVER.c keypad.c Ringtone.c voice_prompt_ctl.c voice_prompt_data_1.c voice_prompt_data_2.c voice_command_ctl.c voice_command_data_1.c voice_command_data_2.c VoicePrompt.c VoiceCommand.c Peq_HPF.c AudioControl_1520.obj DRIVER_1520.c Driver_FM.c Driver_Key.c AudioControl_1520HW.obj Driver_LED.c Driver_Temp.c voice_command_adaption_data_ctl.c voice_command_adaption_data.c DemoSound.c Audio_Transparency.c
  group GAP
    ./source/GAP/: GAP.obj
  group HFP
    ./source/HFP/: HFP.c HFP_Core.c HFP_ServiceRecord.c
  group L2CAP
    ./source/L2CAP/: L2CAP.obj L2CAP_low_energy.obj L2CAP_resource_manager.obj L2CAP_signaling.obj
  group MMI
    ./source/MMI/: MMI.c MMI_Base.c MMI_ChgBat.c MMI_Driver.c MMI_Protocol.c MMI_State.c MMI_Timer.c MMI_SDAP.c MMI_A2DP.c MMI_HFP.c MMI_SectorManager.c MMI_ServiceRecord.c MMI_HCI.c MMI_AirModule.c MMI_AVRCP.c MMI_FM.c MMI_TestMode.c MMI_LineIn.c MMI_TrspXport.c MMI_Reconnect.c MMI_Inquiry.c MMI_LED.c MMI_FCD.c MMI_HID.c
  group MMI_FUNCTION
    ./source/MMI_FUNCTION/: MMI_Air_Function.obj
  group RFCOMM
    ./source/RFCOMM/: RFCOMM.obj rfcomm_crc.obj rfcomm_frame.obj
  group SDAP
    ./source/SDAP/: SDAP.obj
  group AVCTP
    ./source/AVCTP/: AVCTP.obj
  group AVDTP
    ./source/AVDTP/: AVDTP.c
  group A2DP
    ./source/A2DP/: A2DP.c A2DP_MediaChannel.obj A2DP_SignalChannel.c A2DP_ServiceRecord.c
  group AVRCP
    ./source/AVRCP/: AVRCP.c AVRCP_ServiceRecord.c
  group DSP
    ./source/DSP/: DSP.c DSP_ROM_CODE.asm
  group SAP
    ./source/SAP/: SAP.obj
  group OBEX
    ./source/OBEX/: OBEX.obj
  group OPP
    ./source/OPP/: OPP.obj OPP_ServiceRecord.obj
  group PBAP
    ./source/PBAP/: PBAP.obj PBAP_ServiceRecord.obj
  group MAP
    ./source/MAP/: MAP.obj MAP_ServiceRecord.obj
  group SPP
    ./source/SPP/: SPP.c SPP_ServiceRecord.c
  group LCIF
    ./source/LCIF/: LCIF.obj LCIF_app.obj LCIF_ServiceRecord.obj
  group iAP2
    ./source/iAP2/: iAP2.obj iAP2_app.obj iAP2_ServiceRecord.obj
  group SongPal
    ./source/SongPal/: SongPal.obj SongPal_ServiceRecord.obj
  group AirApp
    ./source/APP/: APP.c chacha20.obj
    ./source/AirApp/: AirApp.c AirApp_ServiceRecord.c
  group MMI_LE
    ./source/MMI_LE/: MMI_LE.c lic_hal.c link_index_ctl.c
  group ATT
    ./source/ATT/: ATT_Server.c ATT.obj
  group GATT
    ./source/GATT/: GATT.obj
  group SM
    ./source/SM/: sm_hal.obj SM.obj
  group LE_XPORT
    ./source/LE_XPORT/: le_xport.obj
  group BLE_Service
    ./source/BLE_Service/: BLE_ANCS_C.c
  group HID
    ./source/HID/: HID.c SDAP_HidServiceRecord.c
  group Patch
    ./Patch/: AB1520C_Patch.asm
  group APP_ANCS
    ./source/APP_ANCS/: APP_ANCS.c
  group SDK_example
    ./source/SDK/example/Pedometer/: Pedometer.c xl362.c
  group SDK_IOSYS
    ./source/SDK/IOSYS/: Led.c Pio.c IIC.c Spi.c Key.c Battery.c Charger.c Fm_Hal.c System.c Uart.c Uart_Hal.c NvRam.c Mem.c DSP_Status.c RingtoneVoicePrompt.c
  group SDK_BT
    ./source/SDK/BT/: SDK_Main.c
  group SDK_Proxy
    ./source/SDK_Proxy/: SDK_Proxy.c
  group SDK_IODrv
    ./source/SDK/IODrv/: FmDrv.c AmpDrv.c
  group SDK_Profile
    ./source/SDK/Profile/: A2DP_VendorCodec.c VendorProfile.c VendorProfile_ServiceRecord.c SDK_A2DP.c SDK_AVRCP.c SDK_HCI.c SDK_HFP.c SDK_Profile.c SDK_AirAppCustomer.c SDK_SDP.c
  group HCONST_END
    ./source/COMMON/: HCONST_Sentinel.obj
  group BootCode
    ./source/COMMON/: BootCode.obj
    ./output/AB1520C_BootCode/: BTStereoHeadset_AB1520C_BootCode
    ./output/AB1520D_BootCode/: BTStereoHeadset_AB1520D_BootCode
target AB1520D_Release_Flash (MCS-251)
  device: DQ80251CFG Digital Core Design
  cpu: IRAM(0 - 0x1000) CLOCK(50000000) IROM(0xFF0000-0xFFFFFF)
  output: BTStereoHeadset_AB1520D_AiroStereoHeadset +hex
  asm define: FLASH_INIT=1,AB1520D=1,MIGRATE_ROM_TO_FLASH=1,DFU_LOADER_IN_BOOT_CODE=1
  asm include: .\source\common;.\source\ROM\COMMON
